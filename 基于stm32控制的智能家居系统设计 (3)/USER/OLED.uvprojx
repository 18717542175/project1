# Keil uVision project OLED.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LED +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE;..\HARDWARE\OLED;..\HARDWARE\DHT11;..\HARDWARE\ADC;..\HARDWARE\BEEP;..\HARDWARE\TIMER;..\HARDWARE\RELAY;..\HARDWARE\HC05;..\HARDWARE\USART2;..\HARDWARE\PWM;..\HARDWARE\AIRFAN;..\HARDWARE\HCSR501;..\HARDWARE\KEY;..\HARDWARE\TIMER;..\HARDWARE\usart3;..\HARDWARE\SYN6288;..\HARDWARE\ULN2003;..\HARDWARE\RC522\rc522_config;..\HARDWARE\RC522\rc522_function;..\HARDWARE\RC522\read_card;..\HARDWARE\FIRE
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/OLED/: OLED_I2C.c
    ../HARDWARE/DHT11/: dht11.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/BEEP/: BEEP.c
    ../HARDWARE/TIMER/: timer.c watchdog.c
    ../HARDWARE/RELAY/: RELAY.C
    ../HARDWARE/HC05/: hc05.c
    ../HARDWARE/USART2/: usart2.c
    ../HARDWARE/PWM/: pwm.c
    ../HARDWARE/AIRFAN/: airfan.c
    ../HARDWARE/HCSR501/: hcsr501.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/SYN6288/: syn6288.c
    ../HARDWARE/usart3/: usart3.c
    ../HARDWARE/ULN2003/: ULN2003.c
    ../HARDWARE/RC522/rc522_config/: rc522_config.c
    ../HARDWARE/RC522/rc522_function/: rc522_function.c
    ../HARDWARE/RC522/read_card/: read_card.c
    ../HARDWARE/FIRE/: fire.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_i2c.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_wwdg.c
  group README
    ../: README.TXT
